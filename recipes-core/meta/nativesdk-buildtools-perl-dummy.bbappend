FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

DUMMYPROVIDES += "\
    nativesdk-perl-module-overloading \
    nativesdk-perl-module-symbol \
    nativesdk-perl-module-file-spec \
    nativesdk-perl-module-file-spec-unix \
    "
